Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-12-06T02:54:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Dec 06 02:54:44 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\b46bc5ab-29c6-4dd7-93a7-e1296e8c416d\adc3eeb9-769e-4cb3-9ffc-0fc1601c8749\ifc * Database version: 5507 * Database creation date: Tue Dec 06 02:54:43 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Dec 06 02:54:43 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Dec 06 02:54:43 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11494700_RU_G5265SCViXXL_ED:21526562_RU_11494700_G5265SCViXXL_ED, (2)
In: Default
Type - Material: z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 21526562_RU_11494700_G5265SCViXXL_ED
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 21526562_RU_11494700_G5265SCViXXL_ED
Type - Pset_ProvisionForVoid - Width: 598 mm; Height: 845 mm; Depth: 570 mm
Material: z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Design_Zinc_Steel, Polypropylene, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcDistributionPort, Port_357483
Description: Flow; FlowDirection: SOURCEANDSINK
